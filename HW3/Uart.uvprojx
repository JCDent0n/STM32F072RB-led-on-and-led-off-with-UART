# Keil uVision project Uart.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Uart
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\incl
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c rcc.c uart.c uart.h
    ./incl/: rcc.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
